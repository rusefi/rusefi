# IAR project ch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\; ..\chibios\os\kernel\include; ..\chibios\os\ports\common\ARMCMx; ..\chibios\os\ports\common\ARMCMx\CMSIS\include; ..\chibios\os\ports\IAR\ARMCMx; ..\chibios\os\ports\IAR\ARMCMx\STM32F0xx; ..\chibios\os\hal\include; ..\chibios\os\hal\platforms\STM32; ..\chibios\os\hal\platforms\STM32\DMAv1; ..\chibios\os\hal\platforms\STM32\GPIOv2; ..\chibios\os\hal\platforms\STM32\I2Cv1; ..\chibios\os\hal\platforms\STM32\SPIv1; ..\chibios\os\hal\platforms\STM32\TIMv1; ..\chibios\os\hal\platforms\STM32\RTCv2; ..\chibios\os\hal\platforms\STM32\USARTv1; ..\chibios\os\hal\platforms\STM32\OTGv1; ..\chibios\os\hal\platforms\STM32F0xx; ..\chibios\os\various; ..\chibios\os\various\devices_lib\accel; ..\chibios\boards\ST_STM32F0_DISCOVERY; ..\controllers; ..\controllers\algo; ..\controllers\core; ..\controllers\system; ..\controllers\sensors; ..\controllers\math; ..\controllers\trigger; ..\console; ..\config; ..\config\engines; ..\config\stm32f0egt; ..\console\tunerstudio; ..\console_util; ..\emulation; ..\emulation\test; ..\emulation\hw_layer; ..\hw_layer\algo; ..\hw_layer\lcd; ..\hw_layer\stm32f0; ..\hw_layer\serial_over_usb; ..\hw_layer; ..\ext; ..\ext_algo; ..\emulation; ..\emulation\hw_layer; ..\util
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..; ..\chibios\os\ports\IAR\ARMCMx\STM32F0xx; ..\chibios\boards\ST_STM32F0_DISCOVERY
  OBJCOPY.OOCOutputFile: iar.hex
  ILINK.IlinkOutputFile: ch.out
  ILINK.IlinkIcfFile: ch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\; ..\chibios\os\kernel\include; ..\chibios\os\ports\common\ARMCMx; ..\chibios\os\ports\common\ARMCMx\CMSIS\include; ..\chibios\os\ports\IAR\ARMCMx; ..\chibios\os\ports\IAR\ARMCMx\STM32F0xx; ..\chibios\os\hal\include; ..\chibios\os\hal\platforms\STM32; ..\chibios\os\hal\platforms\STM32\DMAv1; ..\chibios\os\hal\platforms\STM32\GPIOv2; ..\chibios\os\hal\platforms\STM32\SPIv1; ..\chibios\os\hal\platforms\STM32\TIMv1; ..\chibios\os\hal\platforms\STM32\USARTv1; ..\chibios\os\hal\platforms\STM32F0xx; ..\chibios\os\various; ..\chibios\os\various\devices_lib\accel; ..\chibios\boards\ST_STM32F0_DISCOVERY; ..\..\..\test
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ch.hex
  group (top)
    ../: chconf.h global.h halconf.h main.cpp main.h mcuconf.h rusefi.h svnversion.h
  group config/stm32f0egt
    ../config/stm32f0egt/: chconf.h efifeatures.h halconf.h mcuconf.h
  group console
    ../console/: console_io.c console_io.h eficonsole.c eficonsole.h status_loop.h
  group console/tunerstudio
    ../console/tunerstudio/: tunerstudio.h tunerstudio_algo.h tunerstudio_configuration.h
  group console_util
    ../console_util/: datalogging.c datalogging.h rfiutil.c rfiutil.h
  group controllers
    ../controllers/: engine_controller.h error_handling.c flash_main.h idle_thread.h settings.h
    ../controllers/algo/: enum_strings.h
  group controllers/algo
    ../controllers/algo/: auto_generated_enums.h can_header.h ec2.h engine.h engine_configuration.h engine_state.h error_handling.h fuel_math.h idle_controller.h io_pins.h main_trigger_callback.h malfunction_central.h map_adjuster.h nmea.h obd_error_codes.h rusefi_enums.h signal_executor.h
  group controllers/math
    ../controllers/math/: efitime.h
  group controllers/sensors
    ../controllers/sensors/: allsensors.h sensor_types.h
  group controllers/system
    ../controllers/system/: efiGpio.h scheduler.h
  group emulation/hw_layer
    ../emulation/hw_layer/: poten.h
  group ext
    ../ext/: diskio.h ff.h ffconf.h integer.h
  group hw_layer
    ../hw_layer/: adc_external.h adc_inputs.h AdcConfiguration.h board_test.h can_hw.cpp can_hw.h flash.h gpio_helper.h hardware.h max31855.cpp max31855.h mcp3208.h pin_repository.h
  group hw_layer/algo
    ../hw_layer/algo/: adc_math.h
  group hw_layer/lcd
    ../hw_layer/lcd/: lcd_HD44780.h
  group hw_layer/serial_over_usb
    ../hw_layer/serial_over_usb/: usbcfg.h usbconsole.h
  group hw_layer/stm32f0
    ../hw_layer/stm32f0/: mpu_util.cpp mpu_util.h
  group os/board
    ../chibios/boards/ST_STM32F0_DISCOVERY/: board.c board.h
  group os/hal/include
    ../chibios/os/hal/include/: adc.h can.h ext.h gpt.h hal.h i2c.h icu.h mac.h mii.h mmc_spi.h pal.h pwm.h rtc.h sdc.h serial.h serial_usb.h spi.h uart.h usb.h usb_cdc.h
  group os/hal/src
    ../chibios/os/hal/src/: adc.c can.c ext.c gpt.c hal.c i2c.c icu.c mac.c mmc_spi.c mmcsd.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c uart.c usb.c
    ../chibios/os/hal/platforms/STM32/: ext_lld.c
    ../chibios/os/hal/platforms/STM32F0xx/: ext_lld_isr.c
  group os/kernel/include
    ../chibios/os/kernel/include/: ch.h chcond.h chdebug.h chdynamic.h chevents.h chheap.h chinline.h chioch.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group os/kernel/src
    ../chibios/os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
  group os/platform
    ../chibios/os/hal/platforms/STM32F0xx/: adc_lld.c adc_lld.h hal_lld.c hal_lld.h stm32_dma.c stm32_dma.h
    ../chibios/os/hal/platforms/STM32/: can_lld.c can_lld.h
    ../chibios/os/hal/platforms/STM32/TIMv1/: gpt_lld.c gpt_lld.h icu_lld.c icu_lld.h pwm_lld.c pwm_lld.h stm32_tim.h
    ../chibios/os/hal/platforms/STM32/I2Cv1/: i2c_lld.c i2c_lld.h
    ../chibios/os/hal/platforms/STM32/GPIOv2/: pal_lld.c pal_lld.h
    ../chibios/os/hal/platforms/STM32/RTCv2/: rtc_lld.c rtc_lld.h
    ../chibios/os/hal/platforms/STM32/USARTv1/: serial_lld.c serial_lld.h
    ../chibios/os/hal/platforms/STM32/SPIv1/: spi_lld.c spi_lld.h
    ../chibios/os/hal/platforms/STM32/OTGv1/: stm32_otg.h usb_lld.c usb_lld.h
    ../chibios/os/hal/platforms/STM32F4xx/: stm32_rcc.h stm32f4xx.h
  group os/port
    ../chibios/os/ports/IAR/ARMCMx/: chcore.c chcore.h chcore_v7m.c chcore_v7m.h chcoreasm_v7m.s chtypes.h cstartup.s
    ../chibios/os/ports/common/ARMCMx/: nvic.c nvic.h
  group os/port/STM32F0xx
    ../chibios/os/ports/IAR/ARMCMx/STM32F0xx/: cmparams.h vectors.s
  group os/various
    ../chibios/os/various/: chprintf.c chprintf.h memstreams.c memstreams.h
  group util
    ../util/: cli_registry.c cli_registry.h crc.h cyclic_buffer.h data_buffer.h efilib.cpp efilib.h efilib2.h histogram.h listener_array.h
