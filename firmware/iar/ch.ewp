# IAR project ch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\; ..\ChibiOS\os; ..\ChibiOS\os\common; ..\ChibiOS\os\common\ports; ..\ChibiOS\os\common\ports\ARMCMx; ..\ChibiOS\os\common\ports\ARMCMx\compilers; ..\ChibiOS\os\common\ports\ARMCMx\compilers\IAR; ..\ChibiOS\os\common\ports\ARMCMx\devices; ..\ChibiOS\os\common\ports\ARMCMx\devices\STM32F4xx; ..\ChibiOS\os\common\startup; ..\ChibiOS\os\ext; ..\ChibiOS\os\ext\CMSIS; ..\ChibiOS\os\ext\CMSIS\include; ..\ChibiOS\os\ext\CMSIS\ST; ..\ChibiOS\os\ext\CMSIS\ST\STM32F4xx; ..\ChibiOS\os\hal; ..\ChibiOS\os\hal\include; ..\ChibiOS\os\hal\lib; ..\ChibiOS\os\hal\lib\streams; ..\ChibiOS\os\hal\osal; ..\ChibiOS\os\hal\osal\rt; ..\ChibiOS\os\hal\ports; ..\ChibiOS\os\hal\ports\common; ..\ChibiOS\os\hal\ports\common\ARMCMx; ..\ChibiOS\os\hal\ports\STM32; ..\ChibiOS\os\hal\ports\STM32\LLD; ..\ChibiOS\os\hal\ports\STM32\LLD\ADCv2; ..\ChibiOS\os\hal\ports\STM32\LLD\CANv1; ..\ChibiOS\os\hal\ports\STM32\LLD\DACv1; ..\ChibiOS\os\hal\ports\STM32\LLD\DMAv1; ..\ChibiOS\os\hal\ports\STM32\LLD\DMAv2; ..\ChibiOS\os\hal\ports\STM32\LLD\EXTIv1; ..\ChibiOS\os\hal\ports\STM32\LLD\GPIOv2; ..\ChibiOS\os\hal\ports\STM32\LLD\I2Cv1; ..\ChibiOS\os\hal\ports\STM32\LLD\OTGv1; ..\ChibiOS\os\hal\ports\STM32\LLD\RTCv2; ..\ChibiOS\os\hal\ports\STM32\LLD\SDIOv1; ..\ChibiOS\os\hal\ports\STM32\LLD\SPIv1; ..\ChibiOS\os\hal\ports\STM32\LLD\TIMv1; ..\ChibiOS\os\hal\ports\STM32\LLD\USARTv1; ..\ChibiOS\os\hal\ports\STM32\LLD\USARTv2; ..\ChibiOS\os\hal\ports\STM32\STM32F4xx; ..\ChibiOS\os\hal\src; ..\ChibiOS\os\rt; ..\ChibiOS\os\rt\dox; ..\ChibiOS\os\rt\include; ..\ChibiOS\os\rt\ports; ..\ChibiOS\os\rt\ports\ARMCMx; ..\ChibiOS\os\rt\ports\ARMCMx\cmsis_os; ..\ChibiOS\os\rt\ports\ARMCMx\compilers; ..\ChibiOS\os\rt\ports\ARMCMx\compilers\IAR; ..\ChibiOS\os\rt\src; ..\ChibiOS\os\various; ..\ChibiOS\os\various\cpp_wrappers; ..\ChibiOS\os\various\devices_lib; ..\ChibiOS\os\various\devices_lib\accel; ..\ChibiOS\os\various\fatfs_bindings; ..\ChibiOS\os\various\shell; ..\controllers; ..\controllers\algo; ..\controllers\core; ..\controllers\system; ..\controllers\sensors; ..\controllers\math; ..\controllers\trigger; ..\controllers\trigger\decoders; ..\console; ..\config; ..\config\boards\ST_STM32F4; ..\config\engines; ..\config\stm32f4ems; ..\console\binary; ..\console_util; ..\development; ..\development\test; ..\development\hw_layer; ..\hw_layer\algo; ..\hw_layer\lcd; ..\hw_layer\stm32f4; ..\hw_layer\mass_storage; ..\hw_layer\sensors; ..\hw_layer\serial_over_usb; ..\hw_layer; ..\ext; ..\ext_algo; ..\development; ..\development\hw_layer; ..\util
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..; ..\chibios\os\ports\IAR\ARMCMx\STM32F4xx; ..\chibios\boards\ST_STM32F4_DISCOVERY
  OBJCOPY.OOCOutputFile: iar.hex
  ILINK.IlinkOutputFile: ch.out
  ILINK.IlinkIcfFile: ch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\; ..\ChibiOS\os\hal\boards\ST_STM32F2_DISCOVERY\cfg; ..\ChibiOS\os\hal\boards\ST_STM32F3_DISCOVERY; ..\ChibiOS\os\hal\boards\ST_STM32F3_DISCOVERY\cfg; ..\ChibiOS\os\hal\boards\ST_STM32F401C_DISCOVERY; ..\ChibiOS\os\hal\boards\ST_STM32F401C_DISCOVERY\cfg; ..\ChibiOS\os\hal\boards\ST_STM32F429I_DISCOVERY; ..\ChibiOS\os\hal\boards\ST_STM32F429I_DISCOVERY\cfg; ..\ChibiOS\os\hal\boards\ST_STM32F4_DISCOVERY; ..\ChibiOS\os\hal\boards\ST_STM32F4_DISCOVERY\cfg; ..\ChibiOS\os\hal\boards\ST_STM32F746G_DISCOVERY; ..\ChibiOS\os\hal\boards\ST_STM32F746G_DISCOVERY\cfg; ..\ChibiOS\os\hal\boards\ST_STM32L476_DISCOVERY; ..\ChibiOS\os\hal\boards\ST_STM32L476_DISCOVERY\cfg; ..\ChibiOS\os\hal\boards\ST_STM32L_DISCOVERY; ..\ChibiOS\os\hal\boards\ST_STM32L_DISCOVERY\cfg; ..\ChibiOS\os\hal\boards\ST_STM32VL_DISCOVERY; ..\ChibiOS\os\hal\boards\ST_STM8L_DISCOVERY; ..\ChibiOS\os\hal\boards\ST_STM8S_DISCOVERY; ..\config\stm32f4ems; ..\..\..\test
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ch.hex
  group (top)
    ../: global.h main.cpp main.h rusefi.cpp rusefi.h svnversion.h
  group ChibiOS/os/common/ports/ARMCMx/compilers/GCC
    ../ChibiOS/os/common/ports/ARMCMx/compilers/GCC/: crt1.c vectors.c vectors.h
  group ChibiOS/os/common/ports/ARMCMx/devices/STM32F4xx
    ../ChibiOS/os/common/ports/ARMCMx/devices/STM32F4xx/: cmparams.h
  group ChibiOS/os/ext/CMSIS/include
    ../ChibiOS/os/ext/CMSIS/include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group ChibiOS/os/ext/CMSIS/ST/STM32F4xx
    ../ChibiOS/os/ext/CMSIS/ST/STM32F4xx/: stm32f401xc.h stm32f401xe.h stm32f405xx.h stm32f407xx.h stm32f410cx.h stm32f410rx.h stm32f410tx.h stm32f411xe.h stm32f415xx.h stm32f417xx.h stm32f427xx.h stm32f429xx.h stm32f437xx.h stm32f439xx.h stm32f446xx.h stm32f469xx.h stm32f479xx.h stm32f4xx.h system_stm32f4xx.h
  group ChibiOS/os/hal/include
    ../ChibiOS/os/hal/include/: adc.h can.h dac.h ext.h gpt.h hal.h hal_buffers.h hal_channels.h hal_files.h hal_ioblock.h hal_mmcsd.h hal_queues.h hal_streams.h i2c.h i2s.h icu.h mac.h mii.h mmc_spi.h pal.h pwm.h rtc.h sdc.h serial.h serial_usb.h spi.h st.h uart.h usb.h usb_cdc.h wdg.h
  group ChibiOS/os/hal/lib/streams
    ../ChibiOS/os/hal/lib/streams/: chprintf.c chprintf.h memstreams.c memstreams.h nullstreams.c nullstreams.h
  group ChibiOS/os/hal/osal/rt
    ../ChibiOS/os/hal/osal/rt/: osal.c osal.h
  group ChibiOS/os/hal/ports/common/ARMCMx
    ../ChibiOS/os/hal/ports/common/ARMCMx/: mpu.h nvic.c nvic.h
  group ChibiOS/os/hal/ports/STM32/LLD/ADCv2
    ../ChibiOS/os/hal/ports/STM32/LLD/ADCv2/: adc_lld.c adc_lld.h
  group ChibiOS/os/hal/ports/STM32/LLD/CANv1
    ../ChibiOS/os/hal/ports/STM32/LLD/CANv1/: can_lld.c can_lld.h
  group ChibiOS/os/hal/ports/STM32/LLD/DACv1
    ../ChibiOS/os/hal/ports/STM32/LLD/DACv1/: dac_lld.c dac_lld.h
  group ChibiOS/os/hal/ports/STM32/LLD/DMAv2
    ../ChibiOS/os/hal/ports/STM32/LLD/DMAv2/: stm32_dma.c stm32_dma.h
  group ChibiOS/os/hal/ports/STM32/LLD/EXTIv1
    ../ChibiOS/os/hal/ports/STM32/LLD/EXTIv1/: ext_lld.c ext_lld.h
  group ChibiOS/os/hal/ports/STM32/LLD/GPIOv2
    ../ChibiOS/os/hal/ports/STM32/LLD/GPIOv2/: pal_lld.c pal_lld.h
  group ChibiOS/os/hal/ports/STM32/LLD/I2Cv1
    ../ChibiOS/os/hal/ports/STM32/LLD/I2Cv1/: i2c_lld.c i2c_lld.h
  group ChibiOS/os/hal/ports/STM32/LLD/OTGv1
    ../ChibiOS/os/hal/ports/STM32/LLD/OTGv1/: stm32_otg.h usb_lld.c usb_lld.h
  group ChibiOS/os/hal/ports/STM32/LLD/RTCv2
    ../ChibiOS/os/hal/ports/STM32/LLD/RTCv2/: rtc_lld.c rtc_lld.h
  group ChibiOS/os/hal/ports/STM32/LLD/SDIOv1
    ../ChibiOS/os/hal/ports/STM32/LLD/SDIOv1/: sdc_lld.c sdc_lld.h
  group ChibiOS/os/hal/ports/STM32/LLD/SPIv1
    ../ChibiOS/os/hal/ports/STM32/LLD/SPIv1/: i2s_lld.c i2s_lld.h spi_lld.c spi_lld.h
  group ChibiOS/os/hal/ports/STM32/LLD/TIMv1
    ../ChibiOS/os/hal/ports/STM32/LLD/TIMv1/: gpt_lld.c gpt_lld.h icu_lld.c icu_lld.h pwm_lld.c pwm_lld.h st_lld.c st_lld.h stm32_tim.h
  group ChibiOS/os/hal/ports/STM32/LLD/USARTv1
    ../ChibiOS/os/hal/ports/STM32/LLD/USARTv1/: serial_lld.c serial_lld.h uart_lld.c uart_lld.h
  group ChibiOS/os/hal/ports/STM32/STM32F4xx
    ../ChibiOS/os/hal/ports/STM32/STM32F4xx/: ext_lld_isr.c ext_lld_isr.h hal_lld.c hal_lld.h stm32_isr.h stm32_rcc.h stm32_registry.h
  group ChibiOS/os/hal/src
    ../ChibiOS/os/hal/src/: adc.c can.c dac.c ext.c gpt.c hal.c hal_buffers.c hal_mmcsd.c hal_queues.c i2c.c i2s.c icu.c mac.c mmc_spi.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c st.c uart.c usb.c wdg.c
  group ChibiOS/os/rt/include
    ../ChibiOS/os/rt/include/: ch.h chbsem.h chcond.h chcustomer.h chdebug.h chdynamic.h chevents.h chheap.h chlicense.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstats.h chstreams.h chsys.h chsystypes.h chthreads.h chtm.h chvt.h
  group ChibiOS/os/rt/ports/ARMCMx
    ../ChibiOS/os/rt/ports/ARMCMx/: chcore.c chcore.h chcore_timer.h chcore_v6m.c chcore_v6m.h chcore_v7m.c chcore_v7m.h
  group ChibiOS/os/rt/ports/ARMCMx/cmsis_os
    ../ChibiOS/os/rt/ports/ARMCMx/cmsis_os/: cmsis_os.c cmsis_os.h
  group ChibiOS/os/rt/ports/ARMCMx/compilers/GCC
    ../ChibiOS/os/rt/ports/ARMCMx/compilers/GCC/: chtypes.h
  group ChibiOS/os/rt/ports/ARMCMx/compilers/IAR
    ../ChibiOS/os/rt/ports/ARMCMx/compilers/IAR/: chtypes.h
  group ChibiOS/os/rt/src
    ../ChibiOS/os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chvt.c
  group ChibiOS/os/various
    ../ChibiOS/os/various/: evtimer.c evtimer.h shell.c shell.h syscalls.c
  group ChibiOS/os/various/cpp_wrappers
    ../ChibiOS/os/various/cpp_wrappers/: ch.cpp syscalls_cpp.cpp
  group ChibiOS/os/various/devices_lib/accel
    ../ChibiOS/os/various/devices_lib/accel/: lis302dl.c lis302dl.h
  group ChibiOS/os/various/devices_lib/lcd
    ../ChibiOS/os/various/devices_lib/lcd/: lcd3310.c lcd3310.h
  group ChibiOS/os/various/fatfs_bindings
    ../ChibiOS/os/various/fatfs_bindings/: fatfs_diskio.c fatfs_syscall.c
  group ChibiOS/os/various/lwip_bindings
    ../ChibiOS/os/various/lwip_bindings/: lwipthread.c lwipthread.h
  group ChibiOS/os/various/lwip_bindings/arch
    ../ChibiOS/os/various/lwip_bindings/arch/: cc.h perf.h sys_arch.c sys_arch.h
  group config/engines
    ../config/engines/: acura_rsx.cpp acura_rsx.h audi_aan.cpp audi_aan.h bmw_e34.cpp bmw_e34.h chevrolet_c20_1973.cpp chevrolet_c20_1973.h chevrolet_camaro_4.cpp chevrolet_camaro_4.h citroenBerlingoTU3JP.cpp citroenBerlingoTU3JP.h custom_engine.cpp custom_engine.h daihatsu.cpp daihatsu.h dodge_neon.cpp dodge_neon.h dodge_ram.cpp dodge_ram.h dodge_stratus.cpp dodge_stratus.h engines.h ford_1995_inline_6.cpp ford_1995_inline_6.h ford_aspire.cpp ford_aspire.h ford_festiva.cpp ford_festiva.h ford_fiesta.cpp ford_fiesta.h geo_storm.cpp geo_storm.h gm_2_2.cpp gm_2_2.h GY6_139QMB.cpp GY6_139QMB.h honda_600.cpp honda_600.h honda_accord.cpp honda_accord.h lada_kalina.cpp lada_kalina.h mazda_323.cpp mazda_323.h mazda_626.cpp mazda_626.h mazda_miata.cpp mazda_miata.h mazda_miata_1_6.cpp mazda_miata_1_6.h mazda_miata_nb.cpp mazda_miata_nb.h mazda_miata_vvt.cpp mazda_miata_vvt.h MiniCooperR50.cpp MiniCooperR50.h mitsubishi.cpp mitsubishi.h nissan_primera.cpp nissan_primera.h rover_v8.cpp rover_v8.h sachs.cpp sachs.h saturn_ion.cpp saturn_ion.h snow_blower.cpp snow_blower.h subaru.cpp subaru.h suzuki_vitara.cpp suzuki_vitara.h test_engine.cpp test_engine.h toyota_jzs147.cpp toyota_jzs147.h vw.cpp vw.h zil130.cpp zil130.h
  group config/stm32f4ems
    ../config/stm32f4ems/: chconf.h efifeatures.h halconf.h mcuconf.h
  group console
    ../console/: console_io.cpp console_io.h eficonsole.cpp eficonsole.h status_loop.cpp status_loop.h
  group console/binary
    ../console/binary/: tunerstudio.cpp tunerstudio.h tunerstudio_configuration.h tunerstudio_io.cpp tunerstudio_io.h
  group controllers
    ../controllers/: alternatorController.cpp alternatorController.h electronic_throttle.cpp electronic_throttle.h engine_controller.cpp engine_controller.h error_handling.cpp flash_main.cpp flash_main.h idle_thread.cpp idle_thread.h injector_central.cpp injector_central.h lcd_controller.cpp lcd_controller.h malfunction_indicator.cpp malfunction_indicator.h map_averaging.cpp map_averaging.h obd2.cpp obd2.h obd2viaCAN.c PwmTester.cpp PwmTester.h settings.cpp settings.h tachometer.cpp tachometer.h
  group controllers/algo
    ../controllers/algo/: accel_enrichment.cpp accel_enrichment.h advance_map.cpp advance_map.h algo.cpp algo.h auto_generated_enums.cpp auto_generated_enums.h aux_pid.cpp aux_pid.h can_header.h ec2.h engine.cpp engine.h engine_configuration.cpp engine_configuration.h engine_state.h error_handling.h event_registry.cpp event_registry.h fuel_math.cpp fuel_math.h idle_controller.cpp idle_controller.h io_pins.h lcd_menu_tree.cpp lcd_menu_tree.h main_trigger_callback.h malfunction_central.cpp malfunction_central.h map_adjuster.c map_adjuster.h nmea.c nmea.h obd_error_codes.h rusefi_enums.h signal_executor.cpp signal_executor.h
  group controllers/core
    ../controllers/core/: avg_values.cpp avg_values.h EfiWave.cpp EfiWave.h fsio_core.cpp fsio_core.h fsio_impl.cpp fsio_impl.h interpolation.cpp interpolation.h signal_filtering.c signal_filtering.h table_helper.cpp table_helper.h
  group controllers/math
    ../controllers/math/: biquad.cpp biquad.h efitime.h engine_math.cpp engine_math.h pid.cpp pid.h speed_density.cpp speed_density.h
  group controllers/sensors
    ../controllers/sensors/: allsensors.cpp allsensors.h ego.cpp ego.h hip9011_lookup.cpp hip9011_lookup.h maf.cpp maf.h map.cpp map.h sensor_types.h thermistors.cpp thermistors.h tps.cpp tps.h voltage.cpp voltage.h
  group controllers/system
    ../controllers/system/: efiGpio.cpp efiGpio.h event_queue.cpp event_queue.h pwm_generator_logic.cpp pwm_generator_logic.h scheduler.h signal_executor_sleep.cpp signal_executor_sleep.h SingleTimerExecutor.cpp SingleTimerExecutor.h
  group controllers/trigger
    ../controllers/trigger/: main_trigger_callback.cpp rpm_calculator.cpp rpm_calculator.h spark_logic.cpp spark_logic.h trigger_central.cpp trigger_central.h trigger_decoder.cpp trigger_decoder.h trigger_emulator_algo.cpp trigger_emulator_algo.h trigger_simulator.cpp trigger_simulator.h trigger_structure.cpp trigger_structure.h
    ../controllers/trigger/decoders/: trigger_bmw.cpp trigger_bmw.h trigger_chrysler.cpp trigger_chrysler.h trigger_gm.cpp trigger_gm.h trigger_honda.cpp trigger_honda.h trigger_mazda.cpp trigger_mazda.h trigger_mitsubishi.cpp trigger_mitsubishi.h trigger_nissan.cpp trigger_nissan.h trigger_rover.cpp trigger_rover.h trigger_subaru.cpp trigger_subaru.h trigger_toyota.cpp trigger_toyota.h trigger_universal.cpp trigger_universal.h
  group development
    ../development/: engine_emulator.cpp engine_emulator.h engine_sniffer.cpp engine_sniffer.h rfi_perftest.cpp rfi_perftest.h sensor_chart.cpp sensor_chart.h trigger_emulator.cpp trigger_emulator.h wave_analyzer.cpp wave_analyzer.h
  group development/hw_layer
    ../development/hw_layer/: poten.cpp poten.h
  group development/test
    ../development/test/: test.c test.h testbmk.c testbmk.h
  group ext
    ../ext/: diskio.h ff.h ffconf.h integer.h
  group hw_layer
    ../hw_layer/: adc_external.h adc_inputs.cpp adc_inputs.h AdcConfiguration.h board_test.cpp board_test.h can_hw.cpp can_hw.h digital_input_hw.cpp digital_input_hw.h flash.c flash.h gpio_helper.cpp gpio_helper.h hardware.cpp hardware.h HIP9011.cpp HIP9011.h io_pins.cpp joystick.cpp joystick.h max31855.cpp max31855.h mcp3208.c mcp3208.h microsecond_timer.cpp microsecond_timer.h mmc_card.cpp mmc_card.h neo6m.cpp neo6m.h pin_repository.cpp pin_repository.h pwm_generator.cpp pwm_generator.h rtc_helper.cpp rtc_helper.h stepper.cpp stepper.h stm32f4xx_specific.h trigger_input.cpp trigger_input.h vehicle_speed.cpp vehicle_speed.h
  group hw_layer/algo
    ../hw_layer/algo/: adc_math.h
  group hw_layer/boards/ST_STM32F4
    ../config/boards/ST_STM32F4/: board.c board.h
  group hw_layer/lcd
    ../hw_layer/lcd/: lcd_HD44780.cpp lcd_HD44780.h
  group hw_layer/mass_storage
    ../hw_layer/mass_storage/: usb_msd.h usb_msd_cfg.c usb_msd_cfg.h
  group hw_layer/sensors
    ../hw_layer/sensors/: CJ125.cpp CJ125.h
  group hw_layer/serial_over_usb
    ../hw_layer/serial_over_usb/: usbcfg.c usbcfg.h usbconsole.c usbconsole.h
  group hw_layer/stm32f4
    ../hw_layer/stm32f4/: mpu_util.cpp mpu_util.h stm32f4xx_hal_def.h stm32f4xx_hal_flash.c stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h
  group util
    ../util/: cli_registry.cpp cli_registry.h crc.c crc.h cyclic_buffer.cpp cyclic_buffer.h data_buffer.c data_buffer.h datalogging.cpp datalogging.h efilib.cpp efilib.h efilib2.cpp efilib2.h histogram.c histogram.h listener_array.cpp listener_array.h LocalVersionHolder.cpp LocalVersionHolder.h loggingcentral.cpp loggingcentral.h rfiutil.c rfiutil.h
