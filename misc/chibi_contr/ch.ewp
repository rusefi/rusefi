# IAR project ch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\os\rt\include; ..\..\..\..\..\os\rt\ports\ARMCMx; ..\..\..\..\..\os\ext\CMSIS\ST; ..\..\..\..\..\os\ext\CMSIS\include; ..\..\..\..\..\os\rt\ports\ARMCMx\compilers\IAR; ..\..\..\..\..\os\common\ports\ARMCMx\devices\STM32F4xx; ..\..\..\..\..\os\hal\include; ..\..\..\..\..\os\hal\osal\rt; ..\..\..\..\..\os\hal\platforms\STM32; ..\..\..\..\..\os\hal\ports\common\ARMCMx; ..\..\..\..\..\os\hal\ports\STM32\LLD\TIMv1; ..\..\..\..\..\os\hal\ports\STM32\DMAv2; ..\..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2; ..\..\..\..\..\os\hal\ports\STM32\LLD\SPIv1; ..\..\..\..\..\os\hal\ports\STM32\LLD\USARTv1; ..\..\..\..\..\os\hal\ports\STM32\STM32F4xx; ..\..\..\..\..\os\hal\boards\ST_STM32F4_DISCOVERY; ..\..\..\..\..\test
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\..\os\common\ports\ARMCMx\devices\STM32F4xx; ..\..\..\..\..\os\common\ports\ARMCMx\devices\STM32F4xx; ..\..\..\..\..\os\rt\ports\ARMCMx
  OBJCOPY.OOCOutputFile: ch.srec
  ILINK.IlinkOutputFile: ch.out
  ILINK.IlinkIcfFile: ch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\..\os\rt\include; ..\..\..\..\..\os\ports\common\ARMCMx; ..\..\..\..\..\os\ports\common\ARMCMx\CMSIS\include; ..\..\..\..\..\os\ports\IAR\ARMCMx; ..\..\..\..\..\os\ports\IAR\ARMCMx\STM32f4xx; ..\..\..\..\..\os\hal\include; ..\..\..\..\..\os\hal\platforms\STM32; ..\..\..\..\..\os\hal\platforms\STM32\DMAv2; ..\..\..\..\..\os\hal\platforms\STM32\GPIOv2; ..\..\..\..\..\os\hal\platforms\STM32\SPIv1; ..\..\..\..\..\os\hal\platforms\STM32\USARTv1; ..\..\..\..\..\os\hal\platforms\STM32f4xx; ..\..\..\..\..\boards\ST_STM32f4_DISCOVERY; ..\..\..\..\..\test
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  AARM.AUserIncludes: ..; ..\..\..\..\..\os\ports\IAR\ARMCMx\STM32f4xx; ..\..\..\..\..\boards\ST_STM32f4_DISCOVERY
  OBJCOPY.OOCOutputFile: ch.hex
  group (top)
    ../: chconf.h halconf.h main.c mcuconf.h
  group board
    ../../../../../os/hal/boards/ST_STM32f4_DISCOVERY/: board.c
    ../../../../../os/hal/boards/ST_STM32F4_DISCOVERY/: board.h
  group os/hal/include
    ../../../../../os/hal/include/: adc.h can.h ext.h gpt.h hal.h i2c.h icu.h mac.h mii.h mmc_spi.h pal.h pwm.h rtc.h sdc.h serial.h serial_usb.h spi.h tm.h uart.h usb.h usb_cdc.h
  group os/hal/src
    ../../../../../os/hal/src/: adc.c can.c ext.c gpt.c hal.c i2c.c icu.c mac.c mmc_spi.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c st.c uart.c usb.c
  group os/kernel/include
    ../../../../../os/rt/include/: ch.h chcond.h chdebug.h chdynamic.h chevents.h chheap.h chinline.h chioch.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group os/kernel/src
    ../../../../../os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chtm.c chthreads.c chvt.c
  group os/platform
    ../../../../../os/hal/ports/STM32/LLD/TIMv1/: gpt_lld.c st_lld.c gpt_lld.h
    ../../../../../os/hal/ports/STM32/STM32F4xx/: hal_lld.c hal_lld.h stm32_dma.c stm32_dma.h
    ../../../../../os/hal/ports/STM32/LLD/GPIOv2/: pal_lld.c pal_lld.h
    ../../../../../os/hal/ports/STM32/LLD/USARTv1/: serial_lld.c
    ../../../../../os/hal/ports/STM32/USARTv1/: serial_lld.h
    ../../../../../os/hal/ports/STM32/LLD/SPIv1/: spi_lld.c spi_lld.h
    ../../../../../os/hal/ports/STM32f4xx/: stm32f4xx.h
  group os/port
    ../../../../../os/rt/ports/ARMCMx/: chcore.c chcore.h chcore_v7m.c chcore_v7m.h
    ../../../../../os/rt/ports/ARMCMx/compilers/IAR/: chcoreasm_v7m.s
    ../../../../../os/ports/IAR/ARMCMx/: chtypes.h
    ../../../../../os/common/ports/ARMCMx/compilers/IAR/: cstartup.s
    ../../../../../os/hal/ports/common/ARMCMx/: nvic.c nvic.h
  group os/port/STM32F4xx
    ../../../../../os/ports/IAR/ARMCMx/STM32f4xx/: cmparams.h
    ../../../../../os/common/ports/ARMCMx/compilers/IAR/: vectors.s
  group test
    ../../../../../test/rt/: test.c test.h testbmk.c testbmk.h testdyn.c testdyn.h testevt.c testevt.h testheap.c testheap.h testmbox.c testmbox.h testmsg.c testmsg.h testmtx.c testmtx.h testpools.c testpools.h testqueues.c testqueues.h testsem.c testsem.h testthd.c testthd.h
